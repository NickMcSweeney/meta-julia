require julia.bb

PV = "1.10"
MINOR_VERSION = "9"
