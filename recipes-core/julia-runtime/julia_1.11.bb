require julia.bb

PV = "1.11"
MINOR_VERSION = "5"
