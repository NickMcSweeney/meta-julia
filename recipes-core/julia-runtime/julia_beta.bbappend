PV = "1.12"
MINOR_VERSION = "0-beta3"
